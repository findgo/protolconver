# Keil uVision project protolconver.uvprojx, settings and files
target protolconver (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: protolconver +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\bxCommon;..\bxDriver;..\bxDriver\bsp;..\bxDriver\dev;..\bxDriver\npi;..\bxUser\curtain;..\bxModule\mo;..\bxModule\ltl;..\bxModule;..\bxDriver\nwk;..\bxUser
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group bxDriver
    ../bxDriver/: systick.c loop.c hal_key.c bxusart.c
  group bxUser
    ../bxUser/curtain/: curtain.c
    ../bxUser/: ltl_app_genattr.c
  group bxDriver/bsp
    ../bxDriver/bsp/: bsp_spi_flash.c bsp_uniqueID.c
  group bxDriver/dev
    ../bxDriver/dev/: wintom.c
  group bxDriver/npi
    ../bxDriver/npi/: mt_npi.c mt_sapi.c
  group bxDriver/nwk
    ../bxDriver/nwk/: bxnwk.c
  group bxModule
    ../bxModule/: delay.c mclock.c mkey.c mleds.c Mserial.c port_atom.c
  group bxModule/mo
    ../bxModule/mo/: heap_4.c list.c log.c memalloc.c msglink.c queue.c task.c timers.c
  group bxModule/ltl
    ../bxModule/ltl/: ltl.c ltl_general.c ltl_ms.c prefix.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_gpio.c stm32f1xx_ll_pwr.c stm32f1xx_ll_exti.c stm32f1xx_ll_usart.c stm32f1xx_ll_dma.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
