# Keil uVision project protolconver.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: protolconver +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\common;..\dirver;..\module;..\user;..\util;..\dirver\connect;..\module\ltl;..\module\mo;..\dirver\bsp;..\dirver\dev;..\module\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group driver
    ../dirver/: systick.c usart.c loop.c lownv.c nv.c hal_led.c nwk.c
    ../dirver/connect/: dlinkzigbee.c ebyteZB.c
    ../dirver/dev/: wintom.c
  group user
    ../user/: main.c stm32f10x_it.c
  group module
    ../module/: delay.c mclock.c Mserial.c port_atom.c mleds.c mcoils.c mkey.c
    ../module/crypto/: mcrc16.c
  group ltl
    ../module/ltl/: ltl.c prefix.c ltl_general.c ltl_genattr.c ltl_ms.c
  group mo
    ../module/mo/: heap_4.c log.c memalloc.c list.c queue.c timers.c event_groups.c message.c
  group bsp
    ../dirver/bsp/: bsp_uniqueID.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
